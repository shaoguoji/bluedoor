# Keil uVision project bluedoor.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: bluedoor +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: bluedoor.c
